# Keil uVision project DFRobotLCDShield.uvproj, settings and files
target EK-TM4C1294 (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: DFRobotLCDShield
  c flags: Optim=1 uC99=1 wLevel=2
  c define: rvmdk EK_TM4C1294XL PART_TM4C1294NCPDT
  c include: .;.\Board;.\DFRobotLCDShield;.\PrecisionTimer;.\SysProcessor;.\TivaWare;.\util
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group src
    ./: defs.h errno.h error.c main.c main.h startup_rvmdk.s
  group util
    ./util/: util.c util.h
  group Board
    ./Board/: BoardKeys.c BoardKeys.h BoardLeds.c BoardLeds.h
  group SysProcessor
    ./SysProcessor/: SysProcessor.c SysProcessor.h
  group PrecisionTimer
    ./PrecisionTimer/: TTimer.c TTimer.h
  group DFRobotLCDShield
    ./DFRobotLCDShield/: DFRobotLcdShield.c DFRobotLcdShield.h kbd_analog5.h kbd_analog5.c lcd_hd44780.c lcd_hd44780.h
  group TivaWare/inc
    ./TivaWare/inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h tm4c1294ncpdt.h
  group TivaWare/driverlib
    ./TivaWare/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
